# Keil uVision project UART.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UART +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe  --bincombined --output=@L.bin !L
  c flags: Optim=1 OneElfS=1
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --C99   --diag_suppress=550,177,1035,186,69,223,167,1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HALLIB\STM32F4xx_HAL_Driver\Inc\Legacy;..\HARDWARE\BSP_24CXX;..\HARDWARE\BSP_ADC;..\HARDWARE\BSP_BEEP;..\HARDWARE\BSP_FLASH;..\HARDWARE\BSP_IIC;..\HARDWARE\BSP_KEY;..\HARDWARE\BSP_MASTER_I2C;..\HARDWARE\BSP_SPI;..\HARDWARE\BSP_Timer;..\HARDWARE\BSP_GPIO;..\HARDWARE\BSP_IWDG;..\HARDWARE;..\HARDWARE\BSP_UART_FIFO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
    ../HARDWARE/: bsp_command.c bsp_config.h
  group HARDWARE
    ../HARDWARE/BSP_24CXX/: bsp_24cxx.c
    ../HARDWARE/BSP_ADC/: bsp_adc.c
    ../HARDWARE/BSP_IIC/: bsp_myiic.c
    ../HARDWARE/BSP_MASTER_I2C/: bsp_master_i2c.c
    ../HARDWARE/BSP_SPI/: bsp_spi.c
    ../HARDWARE/BSP_Timer/: bsp_timer.c
    ../HARDWARE/BSP_KEY/: bsp_key.c bsp_button.c
    ../HARDWARE/BSP_GPIO/: bsp_gpio.c
    ../HARDWARE/BSP_IWDG/: bsp_iwdg.c
    ../HARDWARE/BSP_BEEP/: bsp_beep.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    E:/Project/OLP/Project-V1.2/SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_cm4.h startup_stm32f411xe.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_iwdg.c
